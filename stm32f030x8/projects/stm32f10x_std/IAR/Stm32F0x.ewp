# IAR project Stm32F0x.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F030x8 ST STM32F030x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F030
  ICCARM.CCIncludePath2: ..\..\..\..\Components\CMSIS\Device\ST\STM32F0xx\Source\Templates\iar; ..\..\..\..\Components\CMSIS\Device\ST\STM32F0xx\Source\Templates; ..\..\..\..\Components\CMSIS\Device\ST\STM32F0xx\Include; ..\..\..\..\Components\STM32F0xx_StdPeriph_Driver\inc; ..\..\..\..\Components\Utilities; ..\..\..\Components; ..\..\..\Components\BSP; ..\..\..\Components\BSP\Stm32F0x_BSP\callback; ..\..\..\Components\BSP\Stm32F0x_BSP\conf; ..\..\..\Components\BSP\Stm32F0x_BSP\inc; ..\..\..\Components\BSP\Stm32F0x_BSP\src; ..\..\..\Components\MDL\clog; ..\..\..\Components\MDL\cshell; ..\..\..\Components\MDL\header; ..\..\..\Components\MDL\ModbusRTU; ..\..\..\Components\MDL\osal\ports; ..\..\..\Components\MDL\osal\src; ..\..\..\Components\MDL\rttviewer; ..\Source\Application\User_Task; ..\Source\FML\Src; ..\Source\FML\System; $PROJ_DIR$; ..\Source\Application; ..\Source\application\hal_task; ..\Source\FML; ..\Source\application\gprs_task; ..\Source\FML\gprs; ..\Source\FML\maintain; ..\Source\FML\zsproto; ..\Source\FML\zsproto\zsproto_p2p; ..\Source\FML\zsproto\zsproto_tcpip; ..\Source\FML\zsproto\zsproto_uart
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Stm32F0x.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group Application
    ../Source/application/: env_var.h main.c self_def.h stm32f0xx_it.c
  group Application/gprs_task
    ../Source/application/gprs_task/: gprs_task.c
  group Application/hal_task
    ../Source/application/hal_task/: hal_task.c
  group Application/user_task
    ../Source/application/user_Task/: user_task.c
  group bsp
    ../../../Components/BSP/: bsp_gprs.c bsp_init.c bsp_led.c
  group bsp/stm32f0x_bsp/src
    ../../../Components/BSP/Stm32F0x_BSP/src/: stm32f0xx_bsp_dma.c stm32f0xx_bsp_gpio.c stm32f0xx_bsp_nvic.c stm32f0xx_bsp_systick.c stm32f0xx_bsp_timer.c stm32f0xx_bsp_usart.c
  group cmsis
    ../../../../Components/CMSIS/Device/ST/STM32F0xx/Source/Templates/iar/: startup_stm32f030.s
    ../../../../Components/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group Driver
    ../../../../Components/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group fml/gprs
    ../Source/FML/gprs/: gprs_cache.c gprs_commond.c gprs_process.c
  group fml/led
    ../Source/FML/led/: led_process.c led_process.h
  group fml/maintain
    ../Source/FML/maintain/: maintain_process.c
  group fml/system
    ../Source/FML/System/: system_info.c system_init.c system_param.c
  group fml/zsproto
    ../Source/FML/zsproto/: zsproto.c zsproto_package_process.c zsproto_penetrate_process.c
  group mdl
    ../../../Components/MDL/: cqueue.c cstring.c
  group mdl/clog
    ../../../Components/MDL/clog/: clog.c flash_log.c rtt_log.c serial_log.c
  group mdl/cshell
    ../../../Components/MDL/cshell/: cshell.c cshell_port.c cshell_user.c
  group mdl/osal/ports
    ../../../Components/MDL/osal/ports/: osal_cpu.c
  group mdl/osal/src
    ../../../Components/MDL/osal/src/: osal.c osal_cfg.c osal_clock.c osal_core.c osal_msg.c osal_task.c osal_timeout.c osal_timer.c
  group mdl/RTTViewer
    ../../../Components/MDL/rttviewer/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group uti
    ../../../../Components/Utilities/: crc.c
