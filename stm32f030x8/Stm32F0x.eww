<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\projects\stm32f10x_std\IAR\Stm32F0x.ewp</path>
  </project>
  <batchBuild/>
</workspace>


